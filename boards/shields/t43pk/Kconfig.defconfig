## boards/shields/t43pk/Kconfig.defconfig
```kconfig
if SHIELD_T43PK

config ZMK_KEYBOARD_NAME
    default "t43pk"

config I2C
    default y
 
endif
```
